# Keil uVision project Library.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Library +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DisplayGroup;.\MainGroup
  group Source Group 1
    ./: STARTUP.A51
  group MainGroup
    ./MainGroup/: main.c
  group DisplayGroup
    ./DisplayGroup/: SMG.c
